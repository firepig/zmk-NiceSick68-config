## config/boards/shields/nicesick68/Kconfig.defconfig
```kconfig
if SHIELD_NICESICK68
    config ZMK_KEYBOARD_NAME
        default "nicesick68"
endif
```
